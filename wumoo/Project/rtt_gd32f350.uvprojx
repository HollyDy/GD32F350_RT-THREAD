# Keil uVision project rtt_gd32f350.uvprojx, settings and files
target wumoo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rtt_gd32f350 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\rtthread\3.0.3\libcpu\arm\cortex-m4;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc;..\Peripherals\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../user/: main.c key.c led.c usart.c
  group rtt/posts
    ../rtthread/3.0.3/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group rtt.src
    ../rtthread/3.0.3/src/: scheduler.c thread.c
  group lib
    ../Peripherals/src/: gd32f3x0_exti.c gd32f3x0_gpio.c gd32f3x0_syscfg.c gd32f3x0_usart.c
software components: CMSIS:CORE 5.1.2, Device:GD32F3x0_StdPeripherals:MISC 1.0.0, Device:GD32F3x0_StdPeripherals:RCU 1.0.0, Device:GD32F3x0_libopt 1.0.0, Device:Startup 1.0.0
